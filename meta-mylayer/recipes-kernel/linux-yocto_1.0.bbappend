FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"
SRC_URL +="file://defconfig"
KCONFIG_MOOD= "alldefconfig"
