require recipes-core/images/core-image-minimal.bb

DESCRIPTION = "A small image just capable of allowing a device to boot and \
is suitable for development work."

#IMAGE_FEATURES += "dev-pkgs"

#IMAGE_INSTALL:append = " bc"

#IMAGE_INSTALL:append = " this-is"

#IMAGE_INSTALL:append = " libanswer libanswer-example "


#IMAGE_FEATURES += "ssh-server-dropbear"


